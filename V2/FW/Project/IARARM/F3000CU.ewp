# IAR project F3000CU.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F205RC ST STM32F205RC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_BREADBOARD; USE_CU_; USE_STDPERIPH_DRIVER; USE_FULL_ASSERT; STM32F2XX
  ICCARM.CCIncludePath2: ..\inc; ..\src; ..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F2xx; ..\..\Libraries\STM32F2xx_StdPeriph_Driver\inc; ..\..\Utilities\CU; ..\..\Utilities\CU\ADC; ..\..\Utilities\CU\ITS; ..\..\Utilities\CU\timer; ..\..\Utilities\Common; ..\..\Utilities\Common\CLI; ..\..\Utilities\Common\Console; ..\..\Utilities\Common\I2C; ..\..\Utilities\Common\PushButton; ..\..\Utilities\Common\Serial; ..\..\Utilities\Common\UID; ..\..\Utilities\Common\ioext; ..\..\Utilities\libs; ..\..\Utilities\Third_Party\FreeRTOS_v9.0.0\portable\IAR\ARM_CM3; ..\..\Utilities\Third_Party\FreeRTOS_v9.0.0\include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\inc
  OBJCOPY.OOCOutputFile: F3000CU.bin
  ILINK.IlinkOutputFile: F3000CU.out
  ILINK.IlinkIcfFile: stm32f2xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: c.out
  group CMSIS
    ../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F2xx/: system_stm32f2xx.c
  group Common/CLI
    ../../Utilities/Common/CLI/: CLI.c CLI.h
  group Common/Console
    ../../Utilities/Common/Console/: console.c console.h
  group Common/I2C
    ../../Utilities/Common/I2C/: I2C.c I2C.h
  group Common/ioext
    ../../Utilities/Common/ioext/: PCA9952.c PCA9952.h
  group Common/PushButton
    ../../Utilities/Common/Pushbutton/: button.c button.h
  group Common/Serial
    ../../Utilities/Common/Serial/: serial.c serial.h
  group Common/UID
    ../../Utilities/Common/UID/: UID.c UID.h
  group CU
    ../../Utilities/CU/: CU.c CU.h
  group CU/ADC
    ../../Utilities/CU/ADC/: ADC.c ADC.h
  group CU/ITS
    ../../Utilities/CU/ITS/: internal_temp_sensor.c internal_temp_sensor.h
  group CU/timer
    ../../Utilities/CU/timer/: timer.c timer.h
  group EWARM
    ./: startup_stm32f2xx.s
  group FreeRTOS
    ../../Utilities/Third_Party/FreeRTOS_v9.0.0/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../inc/: FreeRTOSConfig.h
  group FreeRTOS/include
    ../../Utilities/Third_Party/FreeRTOS_v9.0.0/include/: croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h task.h timers.h
  group FreeRTOS/portable
    ../../Utilities/Third_Party/FreeRTOS_v9.0.0/portable/MemMang/: heap_2.c
    ../../Utilities/Third_Party/FreeRTOS_v9.0.0/portable/IAR/ARM_CM3/: port.c portasm.s portmacro.h
  group libs
    ../../Utilities/libs/: strbuf.c strbuf.h
  group StdPeriphLib
    ../../Libraries/STM32F2xx_StdPeriph_Driver/src/: misc.c stm32f2xx_adc.c stm32f2xx_dma.c stm32f2xx_exti.c stm32f2xx_gpio.c stm32f2xx_i2c.c stm32f2xx_pwr.c stm32f2xx_rcc.c stm32f2xx_spi.c stm32f2xx_syscfg.c stm32f2xx_tim.c stm32f2xx_usart.c
  group User
    ../src/: main.c stm32f2xx_it.c
    ../inc/: main.h stm32f2xx_it.h
